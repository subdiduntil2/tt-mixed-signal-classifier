v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -1520 -1050 -1440 -1050 {
lab=Vdd}
N -1520 -1030 -1440 -1030 {
lab=Iout00}
N -1520 -1010 -1430 -1010 {
lab=Vr}
N -1520 -990 -1440 -990 {
lab=Vdac0}
N -1520 -970 -1440 -970 {
lab=Ibias}
N -1490 -900 -1440 -900 {
lab=Vss}
N -1440 -1030 -1380 -1030 {
lab=Iout00}
N -1520 -950 -1500 -950 {
lab=Vss}
N -1500 -950 -1500 -900 {
lab=Vss}
N -1500 -900 -1490 -900 {
lab=Vss}
N -1380 -1030 -1000 -1030 {
lab=Iout00}
N -2720 -420 -2670 -420 {
lab=Vdd}
N -2720 -400 -2670 -400 {
lab=En}
N -2720 -380 -2670 -380 {
lab=Ibias}
N -2670 -380 -2630 -380 {
lab=Ibias}
N -2630 -380 -2620 -380 {
lab=Ibias}
N -2720 -360 -2690 -360 {
lab=Vss}
N -2690 -360 -2690 -320 {
lab=Vss}
N -1490 -360 -1410 -360 {
lab=Vdd}
N -1490 -340 -1410 -340 {
lab=Iout10}
N -1490 -320 -1400 -320 {
lab=Vref4}
N -1490 -300 -1410 -300 {
lab=Vr}
N -1410 -340 -1350 -340 {
lab=Iout10}
N -1490 -260 -1470 -260 {
lab=Vss}
N -1470 -260 -1470 -210 {
lab=Vss}
N -1470 -210 -1460 -210 {
lab=Vss}
N -1350 -340 -970 -340 {
lab=Iout10}
N -240 -1100 -160 -1100 {
lab=Vdd}
N -240 -1080 -160 -1080 {
lab=Iout01}
N -240 -1060 -150 -1060 {
lab=Vr}
N -240 -1040 -160 -1040 {
lab=Vdac0}
N -210 -950 -160 -950 {
lab=Vss}
N -160 -1080 -100 -1080 {
lab=Iout01}
N -240 -1000 -220 -1000 {
lab=Vss}
N -220 -1000 -220 -950 {
lab=Vss}
N -220 -950 -210 -950 {
lab=Vss}
N -100 -1080 280 -1080 {
lab=Iout01}
N -240 -1020 -160 -1020 {
lab=Iout00}
N -230 -1020 150 -1020 {
lab=Iout00}
N -200 -350 -120 -350 {
lab=Vdd}
N -200 -330 -120 -330 {
lab=Iout11}
N -200 -310 -110 -310 {
lab=Vref4}
N -200 -290 -120 -290 {
lab=Vr}
N -170 -200 -120 -200 {
lab=Vss}
N -120 -330 -60 -330 {
lab=Iout11}
N -200 -250 -180 -250 {
lab=Vss}
N -180 -250 -180 -200 {
lab=Vss}
N -180 -200 -170 -200 {
lab=Vss}
N -60 -330 320 -330 {
lab=Iout11}
N -200 -270 -120 -270 {
lab=Iout10}
N -190 -270 190 -270 {
lab=Iout10}
N -1490 -280 -1400 -280 {
lab=Ibias}
N -1420 -280 -1340 -280 {
lab=Ibias}
N -1450 -970 -1370 -970 {
lab=Ibias}
N 1320 -1070 1360 -1070 {
lab=Iout01}
N 1320 -1050 1360 -1050 {
lab=Iclass0}
N 1320 -1030 1360 -1030 {
lab=Vss}
N 1360 -1070 1420 -1070 {
lab=Iout01}
N 1360 -1050 1420 -1050 {
lab=Iclass0}
N 1360 -1030 1420 -1030 {
lab=Vss}
N 1350 -310 1390 -310 {
lab=Iout11}
N 1350 -290 1390 -290 {
lab=Iclass1}
N 1350 -270 1390 -270 {
lab=Vss}
N 1390 -310 1450 -310 {
lab=Iout11}
N 1390 -290 1450 -290 {
lab=Iclass1}
N 1390 -270 1450 -270 {
lab=Vss}
N 1920 -670 1990 -670 {
lab=Vdd}
N 1920 -650 1990 -650 {
lab=Vss}
N 1920 -630 1990 -630 {
lab=Iout0}
N 1920 -610 1990 -610 {
lab=Iout1}
N 1920 -590 2000 -590 {
lab=Iclass0}
N 1920 -570 2000 -570 {
lab=Iclass1}
N 1920 -550 2000 -550 {
lab=Ibias}
N 1980 -550 2060 -550 {
lab=Ibias}
N 1990 -670 2020 -670 {
lab=Vdd}
N 1990 -650 2020 -650 {
lab=Vss}
N 1990 -630 2020 -630 {
lab=Iout0}
N 1990 -610 2020 -610 {
lab=Iout1}
N 2000 -590 2020 -590 {
lab=Iclass0}
N 2000 -570 2020 -570 {
lab=Iclass1}
N 2020 -630 2230 -630 {
lab=Iout0}
N 2020 -610 2090 -610 {
lab=Iout1}
N -3320 -410 -3250 -410 {
lab=Vref2}
N -3320 -390 -3250 -390 {
lab=Vdd}
N -3320 -370 -3250 -370 {
lab=Vref1}
N -3320 -350 -3250 -350 {
lab=Vss}
N -3320 -330 -3250 -330 {
lab=Vref3}
N -3320 -310 -3250 -310 {
lab=Vref4}
N -3250 -390 -3190 -390 {
lab=Vdd}
N -2630 150 -2600 150 {
lab=Vdd}
N -2600 150 -2590 150 {
lab=Vdd}
N -2630 130 -2590 130 {
lab=Vss}
N -2630 170 -2590 170 {
lab=Vin1dac}
N -2630 190 -2590 190 {
lab=Vin1}
N -2590 130 -2530 130 {
lab=Vss}
N -2590 150 -2530 150 {
lab=Vdd}
N -2590 170 -2530 170 {
lab=Vin1dac}
N -2590 190 -2530 190 {
lab=Vin1}
N -2530 150 -2490 150 {
lab=Vdd}
N -2530 170 -2470 170 {
lab=Vin1dac}
N -2650 460 -2620 460 {
lab=Vdd}
N -2620 460 -2610 460 {
lab=Vdd}
N -2650 440 -2610 440 {
lab=Vss}
N -2650 480 -2610 480 {
lab=Vin2dac}
N -2650 500 -2610 500 {
lab=Vin2}
N -2610 440 -2550 440 {
lab=Vss}
N -2610 460 -2550 460 {
lab=Vdd}
N -2610 480 -2550 480 {
lab=Vin2dac}
N -2610 500 -2550 500 {
lab=Vin2}
N -2550 460 -2510 460 {
lab=Vdd}
N -2550 480 -2490 480 {
lab=Vin2dac}
N -3300 140 -3270 140 {
lab=Vdd}
N -3270 140 -3260 140 {
lab=Vdd}
N -3300 120 -3260 120 {
lab=Vss}
N -3300 160 -3260 160 {
lab=Vin3dac}
N -3300 180 -3260 180 {
lab=Vin3}
N -3260 120 -3200 120 {
lab=Vss}
N -3260 140 -3200 140 {
lab=Vdd}
N -3260 160 -3200 160 {
lab=Vin3dac}
N -3260 180 -3200 180 {
lab=Vin3}
N -3200 140 -3160 140 {
lab=Vdd}
N -3200 160 -3140 160 {
lab=Vin3dac}
N -3320 490 -3290 490 {
lab=Vdd}
N -3290 490 -3280 490 {
lab=Vdd}
N -3320 470 -3280 470 {
lab=Vss}
N -3320 510 -3280 510 {
lab=Vin4dac}
N -3320 530 -3280 530 {
lab=Vin4}
N -3280 470 -3220 470 {
lab=Vss}
N -3280 490 -3220 490 {
lab=Vdd}
N -3280 510 -3220 510 {
lab=Vin4dac}
N -3280 530 -3220 530 {
lab=Vin4}
N -3220 490 -3180 490 {
lab=Vdd}
N -3220 510 -3160 510 {
lab=Vin4dac}
N -3170 510 -3140 510 {
lab=Vin4dac}
N -3140 510 -3100 510 {
lab=Vin4dac}
N -3100 510 -3070 510 {
lab=Vin4dac}
N -4820 -870 -4730 -870 {
lab=Vdd}
N -4730 -870 -4680 -870 {
lab=Vdd}
N -3170 140 -3110 140 {
lab=Vdd}
N -130 -350 -50 -350 {
lab=Vdd}
N -4780 -670 -4730 -670 {
lab=Vr}
N -4730 -670 -4720 -670 {
lab=Vr}
N -4750 -780 -4710 -780 {
lab=Vss}
N -4840 -780 -4740 -780 {
lab=Vss}
N -4770 -560 -4720 -560 {
lab=Vin3}
N -4720 -560 -4710 -560 {
lab=Vin3}
N -4780 -500 -4730 -500 {
lab=Vin2}
N -4730 -500 -4720 -500 {
lab=Vin2}
N -4780 -450 -4730 -450 {
lab=Vin1}
N -4730 -450 -4720 -450 {
lab=Vin1}
N -4770 -620 -4720 -620 {
lab=Vin4}
N -4720 -620 -4710 -620 {
lab=Vin4}
N -3320 -1090 -3270 -1090 {
lab=Vdd}
N -3320 -1070 -3270 -1070 {
lab=Vss}
N -3320 -1050 -3270 -1050 {
lab=Vin1dac}
N -3320 -1030 -3270 -1030 {
lab=Vin2dac}
N -3320 -1010 -3270 -1010 {
lab=Vin3dac}
N -3320 -990 -3270 -990 {
lab=Vindac}
N -3320 -970 -3270 -970 {
lab=Vdac0}
N -3280 -970 -3230 -970 {
lab=Vdac0}
N -3320 -950 -3200 -950 {
lab=Vdac1}
N -3200 -950 -3180 -950 {
lab=Vdac1}
N -3230 -970 -3080 -970 {
lab=Vdac0}
N -4810 -400 -4720 -400 {
lab=En}
N -4720 -400 -4670 -400 {
lab=En}
N -4810 -340 -4720 -340 {
lab=Iout0}
N -4720 -340 -4670 -340 {
lab=Iout0}
N -4820 -270 -4730 -270 {
lab=Iout1}
N -4730 -270 -4680 -270 {
lab=Iout1}
N -1460 -210 -1440 -210 {
lab=Vss}
C {/home/eserlis/vol_ref_gen.sym} -3470 -360 0 0 {name=x1e}
C {/home/eserlis/bump_final.sym} -1670 -1000 0 0 {name=x2}
C {devices/lab_pin.sym} -1450 -1010 0 0 {name=p12 sig_type=std_logic lab=Vr
}
C {devices/lab_pin.sym} -1450 -990 0 0 {name=p13 sig_type=std_logic lab=Vdac0

}
C {devices/lab_pin.sym} -1180 -1030 0 0 {name=p14 sig_type=std_logic lab=Iout00
}
C {/home/eserlis/ref_gen.sym} -2870 -390 0 0 {name=x3}
C {devices/lab_pin.sym} -2680 -400 0 0 {name=p15 sig_type=std_logic lab=En
}
C {devices/lab_pin.sym} -2630 -380 0 0 {name=p22 sig_type=std_logic lab=Ibias
}
C {devices/lab_pin.sym} -2690 -330 0 0 {name=p24 sig_type=std_logic lab=Vss
}
C {/home/eserlis/bump_final.sym} -1640 -310 0 0 {name=x6}
C {devices/lab_pin.sym} -1410 -320 0 0 {name=p32 sig_type=std_logic lab=Vref4
}
C {devices/lab_pin.sym} -1420 -300 0 0 {name=p33 sig_type=std_logic lab=Vr
}
C {devices/lab_pin.sym} -1150 -340 0 0 {name=p39 sig_type=std_logic lab=Iout10
}
C {/home/eserlis/bump_final.sym} -390 -1050 0 0 {name=x14}
C {devices/lab_pin.sym} -160 -1060 0 0 {name=p54 sig_type=std_logic lab=Vr}
C {devices/lab_pin.sym} -170 -1040 0 0 {name=p55 sig_type=std_logic lab=Vdac0

}
C {devices/lab_pin.sym} 100 -1080 0 0 {name=p56 sig_type=std_logic lab=Iout01
}
C {devices/lab_pin.sym} -30 -1020 0 0 {name=p57 sig_type=std_logic lab=Iout00
}
C {/home/eserlis/bump_final.sym} -350 -300 0 0 {name=x15}
C {devices/lab_pin.sym} -120 -310 0 0 {name=p58 sig_type=std_logic lab=Vref4

}
C {devices/lab_pin.sym} -130 -290 0 0 {name=p59 sig_type=std_logic lab=Vr

}
C {devices/lab_pin.sym} 140 -330 0 0 {name=p60 sig_type=std_logic lab=Iout11
}
C {devices/lab_pin.sym} 10 -270 0 0 {name=p61 sig_type=std_logic lab=Iout10
}
C {devices/lab_pin.sym} -1350 -280 0 0 {name=p62 sig_type=std_logic lab=Ibias
}
C {devices/lab_pin.sym} -1380 -970 0 0 {name=p35 sig_type=std_logic lab=Ibias
}
C {/home/eserlis/ccm_nmos.sym} 1170 -1050 0 0 {name=x4}
C {devices/lab_pin.sym} 1410 -1030 0 0 {name=p37 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} 1410 -1050 0 0 {name=p38 sig_type=std_logic lab=Iclass0
}
C {devices/lab_pin.sym} 1410 -1070 0 0 {name=p47 sig_type=std_logic lab=Iout01
}
C {/home/eserlis/ccm_nmos.sym} 1200 -290 0 0 {name=x8}
C {devices/lab_pin.sym} 1440 -270 0 0 {name=p48 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} 1440 -290 0 0 {name=p49 sig_type=std_logic lab=Iclass1
}
C {devices/lab_pin.sym} 1440 -310 0 0 {name=p50 sig_type=std_logic lab=Iout11
}
C {/home/eserlis/wta_pmos.sym} 1770 -610 0 0 {name=x9}
C {devices/lab_pin.sym} 2050 -550 0 0 {name=p36 sig_type=std_logic lab=Ibias
}
C {devices/lab_pin.sym} 2010 -590 0 0 {name=p52 sig_type=std_logic lab=Iclass0
}
C {devices/lab_pin.sym} 2010 -570 0 0 {name=p65 sig_type=std_logic lab=Iclass1
}
C {devices/lab_pin.sym} 2010 -630 0 0 {name=p66 sig_type=std_logic lab=Iout0
}
C {devices/lab_pin.sym} 2010 -650 0 0 {name=p69 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} -3250 -350 0 0 {name=p1 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} -3250 -330 0 0 {name=p2 sig_type=std_logic lab=Vref3
}
C {devices/lab_pin.sym} -3250 -310 0 0 {name=p3 sig_type=std_logic lab=Vref4
}
C {devices/lab_pin.sym} -3250 -370 0 0 {name=p4 sig_type=std_logic lab=Vref1
}
C {devices/lab_pin.sym} -3250 -410 0 0 {name=p5 sig_type=std_logic lab=Vref2
}
C {/home/eserlis/inv_layout.sym} -2780 160 0 0 {name=x10}
C {devices/lab_pin.sym} -2550 130 0 0 {name=p6 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} -2480 170 0 0 {name=p7 sig_type=std_logic lab=Vin1dac
}
C {/home/eserlis/inv_layout.sym} -2800 470 0 0 {name=x16}
C {devices/lab_pin.sym} -2570 440 0 0 {name=p8 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} -2500 480 0 0 {name=p11 sig_type=std_logic lab=Vin2dac
}
C {/home/eserlis/inv_layout.sym} -3450 150 0 0 {name=x17}
C {devices/lab_pin.sym} -3220 120 0 0 {name=p23 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} -3150 160 0 0 {name=p25 sig_type=std_logic lab=Vin3dac
}
C {/home/eserlis/inv_layout.sym} -3470 500 0 0 {name=x18}
C {devices/lab_pin.sym} -3240 470 0 0 {name=p26 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} -3170 510 0 0 {name=p27 sig_type=std_logic lab=Vin4dac
}
C {devices/lab_pin.sym} -130 -200 0 0 {name=p42 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} -1450 -900 0 0 {name=p43 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} -170 -950 0 0 {name=p44 sig_type=std_logic lab=Vss
}
C {devices/iopin.sym} -4690 -870 0 0 {name=p45 lab=Vdd




}
C {devices/lab_pin.sym} -4800 -870 0 0 {name=p46 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -3200 -390 0 0 {name=p51 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -2670 -420 0 0 {name=p53 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -3120 140 0 0 {name=p63 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -2500 150 0 0 {name=p64 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -3190 490 0 0 {name=p67 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -2520 460 0 0 {name=p68 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -1420 -360 0 0 {name=p71 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -1450 -1050 0 0 {name=p72 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -170 -1100 0 0 {name=p73 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -60 -350 0 0 {name=p74 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} 2010 -670 0 0 {name=p75 sig_type=std_logic lab=Vdd
}
C {devices/iopin.sym} -4720 -670 0 0 {name=p76 lab=Vr




}
C {devices/lab_pin.sym} -4760 -670 0 0 {name=p77 sig_type=std_logic lab=Vr}
C {devices/iopin.sym} -4710 -780 0 0 {name=p133 lab=Vss


}
C {devices/lab_pin.sym} -4820 -780 0 0 {name=p134 sig_type=std_logic lab=Vss
}
C {devices/iopin.sym} -4710 -560 0 0 {name=p28 lab=Vin3




}
C {devices/lab_pin.sym} -4750 -560 0 0 {name=p135 sig_type=std_logic lab=Vin3}
C {devices/iopin.sym} -4720 -500 0 0 {name=p136 lab=Vin2




}
C {devices/lab_pin.sym} -4760 -500 0 0 {name=p137 sig_type=std_logic lab=Vin2}
C {devices/iopin.sym} -4720 -450 0 0 {name=p138 lab=Vin1




}
C {devices/lab_pin.sym} -4760 -450 0 0 {name=p139 sig_type=std_logic lab=Vin1}
C {devices/iopin.sym} -4710 -620 0 0 {name=p140 lab=Vin4




}
C {devices/lab_pin.sym} -4750 -620 0 0 {name=p141 sig_type=std_logic lab=Vin4}
C {devices/lab_pin.sym} -3270 -1070 0 0 {name=p10 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} -3230 -970 0 0 {name=p16 sig_type=std_logic lab=Vdac0
}
C {devices/lab_pin.sym} -3200 -950 0 0 {name=p17 sig_type=std_logic lab=Vdac1
}
C {devices/lab_pin.sym} -3280 -1050 0 0 {name=p18 sig_type=std_logic lab=Vin1dac
}
C {devices/lab_pin.sym} -3280 -1030 0 0 {name=p19 sig_type=std_logic lab=Vin2dac
}
C {devices/lab_pin.sym} -3280 -1010 0 0 {name=p20 sig_type=std_logic lab=Vin3dac
}
C {devices/lab_pin.sym} -3280 -990 0 0 {name=p21 sig_type=std_logic lab=Vindac}
C {/home/eserlis/dac.sym} -3470 -1020 0 0 {name=x1}
C {devices/iopin.sym} -4680 -400 0 0 {name=p30 lab=En




}
C {devices/lab_pin.sym} -4790 -400 0 0 {name=p142 sig_type=std_logic lab=En
}
C {devices/lab_pin.sym} -3230 530 0 0 {name=p9 sig_type=std_logic lab=Vin4}
C {devices/lab_pin.sym} -3220 180 0 0 {name=p29 sig_type=std_logic lab=Vin3}
C {devices/lab_pin.sym} -2560 190 0 0 {name=p40 sig_type=std_logic lab=Vin1}
C {devices/lab_pin.sym} -2580 500 0 0 {name=p143 sig_type=std_logic lab=Vin2}
C {devices/lab_pin.sym} -3270 -1090 0 0 {name=p144 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} 1990 -610 0 0 {name=p31 sig_type=std_logic lab=Iout1
}
C {devices/iopin.sym} -4680 -340 0 0 {name=p34 lab=Iout0




}
C {devices/lab_pin.sym} -4790 -340 0 0 {name=p70 sig_type=std_logic lab=Iout0
}
C {devices/iopin.sym} -4690 -270 0 0 {name=p145 lab=Iout1




}
C {devices/lab_pin.sym} -4800 -270 0 0 {name=p146 sig_type=std_logic lab=Iout1
}
C {devices/lab_pin.sym} -1450 -210 0 0 {name=p41 sig_type=std_logic lab=Vss
}
