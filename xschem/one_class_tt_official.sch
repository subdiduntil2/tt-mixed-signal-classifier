v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 1240 -580 1320 -580 {
lab=Vdd}
N 1240 -560 1320 -560 {
lab=Iout00}
N 1240 -540 1330 -540 {
lab=Vr}
N 1240 -520 1320 -520 {
lab=Vdac0}
N 1240 -500 1320 -500 {
lab=Ibias}
N 1270 -430 1320 -430 {
lab=Vss}
N 1320 -560 1380 -560 {
lab=Iout00}
N 1240 -480 1260 -480 {
lab=Vss}
N 1260 -480 1260 -430 {
lab=Vss}
N 1260 -430 1270 -430 {
lab=Vss}
N 1380 -560 1760 -560 {
lab=Iout00}
N 40 50 90 50 {
lab=Vdd}
N 40 70 90 70 {
lab=En}
N 40 90 90 90 {
lab=Ibias}
N 90 90 130 90 {
lab=Ibias}
N 130 90 140 90 {
lab=Ibias}
N 40 110 70 110 {
lab=Vss}
N 70 110 70 150 {
lab=Vss}
N 1270 110 1350 110 {
lab=Vdd}
N 1270 130 1350 130 {
lab=Iout10}
N 1270 150 1360 150 {
lab=Vref4}
N 1270 170 1350 170 {
lab=Vdac1}
N 1350 130 1410 130 {
lab=Iout10}
N 1270 210 1290 210 {
lab=Vss}
N 1290 210 1290 260 {
lab=Vss}
N 1290 260 1300 260 {
lab=Vss}
N 1410 130 1790 130 {
lab=Iout10}
N 2520 -630 2600 -630 {
lab=Vdd}
N 2520 -610 2600 -610 {
lab=Iout01}
N 2520 -590 2610 -590 {
lab=Vr}
N 2520 -570 2600 -570 {
lab=Vdac0}
N 2550 -480 2600 -480 {
lab=Vss}
N 2600 -610 2660 -610 {
lab=Iout01}
N 2520 -530 2540 -530 {
lab=Vss}
N 2540 -530 2540 -480 {
lab=Vss}
N 2540 -480 2550 -480 {
lab=Vss}
N 2660 -610 3040 -610 {
lab=Iout01}
N 2520 -550 2600 -550 {
lab=Iout00}
N 2530 -550 2910 -550 {
lab=Iout00}
N 2560 120 2640 120 {
lab=Vdd}
N 2560 140 2640 140 {
lab=Iout11}
N 2560 160 2650 160 {
lab=Vref4}
N 2560 180 2640 180 {
lab=Vdac1}
N 2590 270 2640 270 {
lab=Vss}
N 2640 140 2700 140 {
lab=Iout11}
N 2560 220 2580 220 {
lab=Vss}
N 2580 220 2580 270 {
lab=Vss}
N 2580 270 2590 270 {
lab=Vss}
N 2700 140 3080 140 {
lab=Iout11}
N 2560 200 2640 200 {
lab=Iout10}
N 1270 190 1360 190 {
lab=Ibias}
N 1340 190 1420 190 {
lab=Ibias}
N 1310 -500 1390 -500 {
lab=Ibias}
N 4080 -600 4120 -600 {
lab=Iout01}
N 4080 -580 4120 -580 {
lab=Iclass0}
N 4080 -560 4120 -560 {
lab=Vss}
N 4120 -600 4180 -600 {
lab=Iout01}
N 4120 -580 4180 -580 {
lab=Iclass0}
N 4120 -560 4180 -560 {
lab=Vss}
N 4110 160 4150 160 {
lab=Iout11}
N 4110 180 4150 180 {
lab=Iclass1}
N 4110 200 4150 200 {
lab=Vss}
N 4150 160 4210 160 {
lab=Iout11}
N 4150 180 4210 180 {
lab=Iclass1}
N 4150 200 4210 200 {
lab=Vss}
N 4680 -200 4750 -200 {
lab=Vdd}
N 4680 -180 4750 -180 {
lab=Vss}
N 4680 -160 4750 -160 {
lab=Iout0}
N 4680 -140 4750 -140 {
lab=Iout1}
N 4680 -120 4760 -120 {
lab=Iclass0}
N 4680 -100 4760 -100 {
lab=Iclass1}
N 4680 -80 4760 -80 {
lab=Ibias}
N 4740 -80 4820 -80 {
lab=Ibias}
N 4750 -200 4780 -200 {
lab=Vdd}
N 4750 -180 4780 -180 {
lab=Vss}
N 4750 -160 4780 -160 {
lab=Iout0}
N 4750 -140 4780 -140 {
lab=Iout1}
N 4760 -120 4780 -120 {
lab=Iclass0}
N 4760 -100 4780 -100 {
lab=Iclass1}
N 4780 -160 4990 -160 {
lab=Iout0}
N 4780 -140 4850 -140 {
lab=Iout1}
N -560 60 -490 60 {
lab=Vref2}
N -560 80 -490 80 {
lab=Vdd}
N -560 100 -490 100 {
lab=Vref1}
N -560 120 -490 120 {
lab=Vss}
N -560 140 -490 140 {
lab=Vref3}
N -560 160 -490 160 {
lab=Vref4}
N -490 80 -430 80 {
lab=Vdd}
N 130 620 160 620 {
lab=Vdd}
N 160 620 170 620 {
lab=Vdd}
N 130 600 170 600 {
lab=Vss}
N 130 640 170 640 {
lab=Vin1dac}
N 130 660 170 660 {
lab=Vin1}
N 170 600 230 600 {
lab=Vss}
N 170 620 230 620 {
lab=Vdd}
N 170 640 230 640 {
lab=Vin1dac}
N 170 660 230 660 {
lab=Vin1}
N 230 620 270 620 {
lab=Vdd}
N 230 640 290 640 {
lab=Vin1dac}
N 110 930 140 930 {
lab=Vdd}
N 140 930 150 930 {
lab=Vdd}
N 110 910 150 910 {
lab=Vss}
N 110 950 150 950 {
lab=Vin2dac}
N 110 970 150 970 {
lab=Vin2}
N 150 910 210 910 {
lab=Vss}
N 150 930 210 930 {
lab=Vdd}
N 150 950 210 950 {
lab=Vin2dac}
N 150 970 210 970 {
lab=Vin2}
N 210 930 250 930 {
lab=Vdd}
N 210 950 270 950 {
lab=Vin2dac}
N -540 610 -510 610 {
lab=Vdd}
N -510 610 -500 610 {
lab=Vdd}
N -540 590 -500 590 {
lab=Vss}
N -540 630 -500 630 {
lab=Vin3dac}
N -540 650 -500 650 {
lab=Vin3}
N -500 590 -440 590 {
lab=Vss}
N -500 610 -440 610 {
lab=Vdd}
N -500 630 -440 630 {
lab=Vin3dac}
N -500 650 -440 650 {
lab=Vin3}
N -440 610 -400 610 {
lab=Vdd}
N -440 630 -380 630 {
lab=Vin3dac}
N -560 960 -530 960 {
lab=Vdd}
N -530 960 -520 960 {
lab=Vdd}
N -560 940 -520 940 {
lab=Vss}
N -560 980 -520 980 {
lab=Vin4dac}
N -560 1000 -520 1000 {
lab=Vin4}
N -520 940 -460 940 {
lab=Vss}
N -520 960 -460 960 {
lab=Vdd}
N -520 980 -460 980 {
lab=Vin4dac}
N -520 1000 -460 1000 {
lab=Vin4}
N -460 960 -420 960 {
lab=Vdd}
N -460 980 -400 980 {
lab=Vin4dac}
N -410 980 -380 980 {
lab=Vin4dac}
N -380 980 -340 980 {
lab=Vin4dac}
N -340 980 -310 980 {
lab=Vin4dac}
N -2060 -400 -1970 -400 {
lab=Vdd}
N -1970 -400 -1920 -400 {
lab=Vdd}
N -410 610 -350 610 {
lab=Vdd}
N 2630 120 2710 120 {
lab=Vdd}
N -2020 -200 -1970 -200 {
lab=Vr}
N -1970 -200 -1960 -200 {
lab=Vr}
N -1990 -310 -1950 -310 {
lab=Vss}
N -2080 -310 -1980 -310 {
lab=Vss}
N -2010 -90 -1960 -90 {
lab=Vin3}
N -1960 -90 -1950 -90 {
lab=Vin3}
N -2020 -30 -1970 -30 {
lab=Vin2}
N -1970 -30 -1960 -30 {
lab=Vin2}
N -2020 20 -1970 20 {
lab=Vin1}
N -1970 20 -1960 20 {
lab=Vin1}
N -2010 -150 -1960 -150 {
lab=Vin4}
N -1960 -150 -1950 -150 {
lab=Vin4}
N -10 -550 40 -550 {
lab=Vdd}
N -10 -530 40 -530 {
lab=Vss}
N -10 -510 40 -510 {
lab=Vin1dac}
N -10 -490 40 -490 {
lab=Vin2dac}
N -10 -470 40 -470 {
lab=Vin3dac}
N -10 -450 40 -450 {
lab=Vin4dac}
N -10 -430 40 -430 {
lab=Vdac0}
N 30 -430 80 -430 {
lab=Vdac0}
N -10 -410 110 -410 {
lab=Vdac1}
N 110 -410 130 -410 {
lab=Vdac1}
N 80 -430 230 -430 {
lab=Vdac0}
N -2050 70 -1960 70 {
lab=En}
N -1960 70 -1910 70 {
lab=En}
N -2050 130 -1960 130 {
lab=Iout0}
N -1960 130 -1910 130 {
lab=Iout0}
N -2060 200 -1970 200 {
lab=Iout1}
N -1970 200 -1920 200 {
lab=Iout1}
N 1300 260 1320 260 {
lab=Vss}
C {devices/lab_pin.sym} 1310 -540 0 0 {name=p12 sig_type=std_logic lab=Vr
}
C {devices/lab_pin.sym} 1310 -520 0 0 {name=p13 sig_type=std_logic lab=Vdac0

}
C {devices/lab_pin.sym} 1580 -560 0 0 {name=p14 sig_type=std_logic lab=Iout00
}
C {devices/lab_pin.sym} 80 70 0 0 {name=p15 sig_type=std_logic lab=En
}
C {devices/lab_pin.sym} 130 90 0 0 {name=p22 sig_type=std_logic lab=Ibias
}
C {devices/lab_pin.sym} 70 140 0 0 {name=p24 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} 1350 150 0 0 {name=p32 sig_type=std_logic lab=Vref4
}
C {devices/lab_pin.sym} 1340 170 0 0 {name=p33 sig_type=std_logic lab=Vdac1
}
C {devices/lab_pin.sym} 1610 130 0 0 {name=p39 sig_type=std_logic lab=Iout10
}
C {devices/lab_pin.sym} 2600 -590 0 0 {name=p54 sig_type=std_logic lab=Vr}
C {devices/lab_pin.sym} 2590 -570 0 0 {name=p55 sig_type=std_logic lab=Vdac0

}
C {devices/lab_pin.sym} 2860 -610 0 0 {name=p56 sig_type=std_logic lab=Iout01
}
C {devices/lab_pin.sym} 2730 -550 0 0 {name=p57 sig_type=std_logic lab=Iout00
}
C {devices/lab_pin.sym} 2640 160 0 0 {name=p58 sig_type=std_logic lab=Vref4

}
C {devices/lab_pin.sym} 2630 180 0 0 {name=p59 sig_type=std_logic lab=Vdac1

}
C {devices/lab_pin.sym} 2900 140 0 0 {name=p60 sig_type=std_logic lab=Iout11
}
C {devices/lab_pin.sym} 2630 200 0 0 {name=p61 sig_type=std_logic lab=Iout10
}
C {devices/lab_pin.sym} 1410 190 0 0 {name=p62 sig_type=std_logic lab=Ibias
}
C {devices/lab_pin.sym} 1380 -500 0 0 {name=p35 sig_type=std_logic lab=Ibias
}
C {devices/lab_pin.sym} 4170 -560 0 0 {name=p37 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} 4170 -580 0 0 {name=p38 sig_type=std_logic lab=Iclass0
}
C {devices/lab_pin.sym} 4170 -600 0 0 {name=p47 sig_type=std_logic lab=Iout01
}
C {devices/lab_pin.sym} 4200 200 0 0 {name=p48 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} 4200 180 0 0 {name=p49 sig_type=std_logic lab=Iclass1
}
C {devices/lab_pin.sym} 4200 160 0 0 {name=p50 sig_type=std_logic lab=Iout11
}
C {devices/lab_pin.sym} 4810 -80 0 0 {name=p36 sig_type=std_logic lab=Ibias
}
C {devices/lab_pin.sym} 4770 -120 0 0 {name=p52 sig_type=std_logic lab=Iclass0
}
C {devices/lab_pin.sym} 4770 -100 0 0 {name=p65 sig_type=std_logic lab=Iclass1
}
C {devices/lab_pin.sym} 4770 -160 0 0 {name=p66 sig_type=std_logic lab=Iout0
}
C {devices/lab_pin.sym} 4770 -180 0 0 {name=p69 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} -490 120 0 0 {name=p1 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} -490 140 0 0 {name=p2 sig_type=std_logic lab=Vref3
}
C {devices/lab_pin.sym} -490 160 0 0 {name=p3 sig_type=std_logic lab=Vref4
}
C {devices/lab_pin.sym} -490 100 0 0 {name=p4 sig_type=std_logic lab=Vref1
}
C {devices/lab_pin.sym} -490 60 0 0 {name=p5 sig_type=std_logic lab=Vref2
}
C {devices/lab_pin.sym} 210 600 0 0 {name=p6 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} 280 640 0 0 {name=p7 sig_type=std_logic lab=Vin1dac
}
C {devices/lab_pin.sym} 190 910 0 0 {name=p8 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} 260 950 0 0 {name=p11 sig_type=std_logic lab=Vin2dac
}
C {devices/lab_pin.sym} -460 590 0 0 {name=p23 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} -390 630 0 0 {name=p25 sig_type=std_logic lab=Vin3dac
}
C {devices/lab_pin.sym} -480 940 0 0 {name=p26 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} -410 980 0 0 {name=p27 sig_type=std_logic lab=Vin4dac
}
C {devices/lab_pin.sym} 2630 270 0 0 {name=p42 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} 1310 -430 0 0 {name=p43 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} 2590 -480 0 0 {name=p44 sig_type=std_logic lab=Vss
}
C {devices/iopin.sym} -1930 -400 0 0 {name=p45 lab=Vdd




}
C {devices/lab_pin.sym} -2040 -400 0 0 {name=p46 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -440 80 0 0 {name=p51 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} 90 50 0 0 {name=p53 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -360 610 0 0 {name=p63 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} 260 620 0 0 {name=p64 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -430 960 0 0 {name=p67 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} 240 930 0 0 {name=p68 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} 1340 110 0 0 {name=p71 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} 1310 -580 0 0 {name=p72 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} 2590 -630 0 0 {name=p73 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} 2700 120 0 0 {name=p74 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} 4770 -200 0 0 {name=p75 sig_type=std_logic lab=Vdd
}
C {devices/iopin.sym} -1960 -200 0 0 {name=p76 lab=Vr




}
C {devices/lab_pin.sym} -2000 -200 0 0 {name=p77 sig_type=std_logic lab=Vr}
C {devices/iopin.sym} -1950 -310 0 0 {name=p133 lab=Vss


}
C {devices/lab_pin.sym} -2060 -310 0 0 {name=p134 sig_type=std_logic lab=Vss
}
C {devices/iopin.sym} -1950 -90 0 0 {name=p28 lab=Vin3




}
C {devices/lab_pin.sym} -1990 -90 0 0 {name=p135 sig_type=std_logic lab=Vin3}
C {devices/iopin.sym} -1960 -30 0 0 {name=p136 lab=Vin2




}
C {devices/lab_pin.sym} -2000 -30 0 0 {name=p137 sig_type=std_logic lab=Vin2}
C {devices/iopin.sym} -1960 20 0 0 {name=p138 lab=Vin1




}
C {devices/lab_pin.sym} -2000 20 0 0 {name=p139 sig_type=std_logic lab=Vin1}
C {devices/iopin.sym} -1950 -150 0 0 {name=p140 lab=Vin4




}
C {devices/lab_pin.sym} -1990 -150 0 0 {name=p141 sig_type=std_logic lab=Vin4}
C {devices/lab_pin.sym} 40 -530 0 0 {name=p10 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} 80 -430 0 0 {name=p16 sig_type=std_logic lab=Vdac0
}
C {devices/lab_pin.sym} 110 -410 0 0 {name=p17 sig_type=std_logic lab=Vdac1
}
C {devices/lab_pin.sym} 30 -510 0 0 {name=p18 sig_type=std_logic lab=Vin1dac
}
C {devices/lab_pin.sym} 30 -490 0 0 {name=p19 sig_type=std_logic lab=Vin2dac
}
C {devices/lab_pin.sym} 30 -470 0 0 {name=p20 sig_type=std_logic lab=Vin3dac
}
C {devices/lab_pin.sym} 30 -450 0 0 {name=p21 sig_type=std_logic lab=Vin4dac}
C {devices/iopin.sym} -1920 70 0 0 {name=p30 lab=En




}
C {devices/lab_pin.sym} -2030 70 0 0 {name=p142 sig_type=std_logic lab=En
}
C {devices/lab_pin.sym} -470 1000 0 0 {name=p9 sig_type=std_logic lab=Vin4}
C {devices/lab_pin.sym} -460 650 0 0 {name=p29 sig_type=std_logic lab=Vin3}
C {devices/lab_pin.sym} 200 660 0 0 {name=p40 sig_type=std_logic lab=Vin1}
C {devices/lab_pin.sym} 180 970 0 0 {name=p143 sig_type=std_logic lab=Vin2}
C {devices/lab_pin.sym} 40 -550 0 0 {name=p144 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} 4750 -140 0 0 {name=p31 sig_type=std_logic lab=Iout1
}
C {devices/iopin.sym} -1920 130 0 0 {name=p34 lab=Iout0




}
C {devices/lab_pin.sym} -2030 130 0 0 {name=p70 sig_type=std_logic lab=Iout0
}
C {devices/iopin.sym} -1930 200 0 0 {name=p145 lab=Iout1




}
C {devices/lab_pin.sym} -2040 200 0 0 {name=p146 sig_type=std_logic lab=Iout1
}
C {devices/lab_pin.sym} 1310 260 0 0 {name=p41 sig_type=std_logic lab=Vss
}
C {/home/eserlis/bump_final_tt.sym} 1090 -530 0 0 {name=x5}
C {/home/eserlis/bump_final_tt.sym} 2370 -580 0 0 {name=x2}
C {/home/eserlis/bump_final_tt.sym} 1120 160 0 0 {name=x6}
C {/home/eserlis/bump_final_tt.sym} 2410 170 0 0 {name=x7}
C {/home/eserlis/ref_gen_tt.sym} -110 80 0 0 {name=x11}
C {/home/eserlis/vol_ref_gen_tt.sym} -710 110 0 0 {name=x3}
C {/home/eserlis/dac_tt.sym} -160 -480 0 0 {name=x1}
C {/home/eserlis/ccm_nmos_tt.sym} 3960 180 0 0 {name=x4}
C {/home/eserlis/ccm_nmos_tt.sym} 3930 -580 0 0 {name=x8}
C {/home/eserlis/wta_pmos_tt.sym} 4530 -140 0 0 {name=x12}
C {/home/eserlis/inv_layout_tt.sym} -690 620 0 0 {name=x9}
C {/home/eserlis/inv_layout_tt.sym} -710 970 0 0 {name=x10}
C {/home/eserlis/inv_layout_tt.sym} -20 630 0 0 {name=x13}
C {/home/eserlis/inv_layout_tt.sym} -40 940 0 0 {name=x14}
