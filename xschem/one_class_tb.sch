v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 290 -470 370 -470 {
lab=Vdd}
N 290 -450 370 -450 {
lab=Iout00}
N 290 -430 380 -430 {
lab=Vr}
N 290 -410 370 -410 {
lab=Vdac0}
N 290 -390 370 -390 {
lab=Ibias}
N 320 -320 370 -320 {
lab=GND}
N 370 -450 430 -450 {
lab=Iout00}
N 290 -370 310 -370 {
lab=GND}
N 310 -370 310 -320 {
lab=GND}
N 310 -320 320 -320 {
lab=GND}
N 430 -450 810 -450 {
lab=Iout00}
N -1260 -560 -1210 -560 {
lab=Vdd}
N -1260 -540 -1210 -540 {
lab=Vss}
N -1260 -520 -1210 -520 {
lab=Vin1}
N -1260 -500 -1210 -500 {
lab=Vin2}
N -1260 -480 -1210 -480 {
lab=Vin3}
N -1260 -460 -1210 -460 {
lab=Vin4}
N -1260 -440 -1210 -440 {
lab=Vdac0}
N -1220 -440 -1170 -440 {
lab=Vdac0}
N -1260 -420 -1140 -420 {
lab=Vdac1}
N -1660 100 -1610 100 {
lab=Vdd}
N -1660 120 -1610 120 {
lab=En}
N -1660 140 -1610 140 {
lab=Ibias}
N -1610 140 -1570 140 {
lab=Ibias}
N -1570 140 -1560 140 {
lab=Ibias}
N -1660 160 -1630 160 {
lab=Vss}
N -1630 160 -1630 200 {
lab=Vss}
N -630 680 -630 720 {
lab=Vdd}
N -630 780 -630 830 {
lab=GND}
N -760 660 -760 700 {
lab=Vss}
N -760 760 -760 810 {
lab=GND}
N 320 220 400 220 {
lab=Vdd}
N 320 240 400 240 {
lab=Iout10}
N 320 260 410 260 {
lab=Vref4}
N 320 280 400 280 {
lab=Vr}
N 350 370 400 370 {
lab=GND}
N 400 240 460 240 {
lab=Iout10}
N 320 320 340 320 {
lab=GND}
N 340 320 340 370 {
lab=GND}
N 340 370 350 370 {
lab=GND}
N 460 240 840 240 {
lab=Iout10}
N -1140 -420 -1120 -420 {
lab=Vdac1}
N -1170 -440 -1020 -440 {
lab=Vdac0}
N 1570 -520 1650 -520 {
lab=Vdd}
N 1570 -500 1650 -500 {
lab=Iout02}
N 1570 -480 1660 -480 {
lab=Vr}
N 1570 -460 1650 -460 {
lab=Vdac0}
N 1600 -370 1650 -370 {
lab=GND}
N 1650 -500 1710 -500 {
lab=Iout02}
N 1570 -420 1590 -420 {
lab=GND}
N 1590 -420 1590 -370 {
lab=GND}
N 1590 -370 1600 -370 {
lab=GND}
N 1710 -500 2090 -500 {
lab=Iout02}
N 1570 -440 1650 -440 {
lab=Iout00}
N 1580 -440 1960 -440 {
lab=Iout00}
N 1610 230 1690 230 {
lab=Vdd}
N 1610 250 1690 250 {
lab=Iout12}
N 1610 270 1700 270 {
lab=Vref4}
N 1610 290 1690 290 {
lab=Vr}
N 1640 380 1690 380 {
lab=GND}
N 1690 250 1750 250 {
lab=Iout12}
N 1610 330 1630 330 {
lab=GND}
N 1630 330 1630 380 {
lab=GND}
N 1630 380 1640 380 {
lab=GND}
N 1750 250 2130 250 {
lab=Iout12}
N 1610 310 1690 310 {
lab=Iout10}
N 1620 310 2000 310 {
lab=Iout10}
N 320 300 410 300 {
lab=Ibias}
N 390 300 470 300 {
lab=Ibias}
N -490 660 -490 700 {
lab=En}
N -490 760 -490 810 {
lab=GND}
N -350 680 -350 720 {
lab=Vr}
N -350 780 -350 830 {
lab=GND}
N 360 -390 440 -390 {
lab=Ibias}
N 3130 -490 3170 -490 {
lab=Iout02}
N 3130 -470 3170 -470 {
lab=Iclass0}
N 3130 -450 3170 -450 {
lab=Vss}
N 3170 -490 3230 -490 {
lab=Iout02}
N 3170 -470 3230 -470 {
lab=Iclass0}
N 3170 -450 3230 -450 {
lab=Vss}
N 3160 270 3200 270 {
lab=Iout12}
N 3160 290 3200 290 {
lab=Iclass1}
N 3160 310 3200 310 {
lab=Vss}
N 3200 270 3260 270 {
lab=Iout12}
N 3200 290 3260 290 {
lab=Iclass1}
N 3200 310 3260 310 {
lab=Vss}
N 3730 -90 3800 -90 {
lab=Vdd}
N 3730 -70 3800 -70 {
lab=Vss}
N 3730 -50 3800 -50 {
lab=Iout0}
N 3730 -30 3800 -30 {
lab=Iout1}
N 3730 -10 3810 -10 {
lab=Iclass0}
N 3730 10 3810 10 {
lab=Iclass1}
N 3730 30 3810 30 {
lab=Ibias}
N 3790 30 3870 30 {
lab=Ibias}
N 3800 -90 3830 -90 {
lab=Vdd}
N 3800 -70 3830 -70 {
lab=Vss}
N 3800 -50 3830 -50 {
lab=Iout0}
N 3800 -30 3830 -30 {
lab=Iout1}
N 3810 -10 3830 -10 {
lab=Iclass0}
N 3810 10 3830 10 {
lab=Iclass1}
N 3830 -50 4040 -50 {
lab=Iout0}
N 3830 -30 3940 -30 {
lab=Iout1}
N 3830 -30 3900 -30 {
lab=Iout1}
N 3900 -30 3930 -30 {
lab=Iout1}
N -2260 110 -2190 110 {
lab=Vref2}
N -2260 130 -2190 130 {
lab=Vdd}
N -2260 150 -2190 150 {
lab=Vref1}
N -2260 170 -2190 170 {
lab=Vss}
N -2260 190 -2190 190 {
lab=Vref3}
N -2260 210 -2190 210 {
lab=Vref4}
N -2190 130 -2130 130 {
lab=Vdd}
N -1880 720 -1850 720 {
lab=Vdd}
N -1850 720 -1840 720 {
lab=Vdd}
N -1880 700 -1840 700 {
lab=Vss}
N -1880 740 -1840 740 {
lab=Vin1}
N -1880 760 -1840 760 {
lab=#net1}
N -1840 700 -1780 700 {
lab=Vss}
N -1840 720 -1780 720 {
lab=Vdd}
N -1840 740 -1780 740 {
lab=Vin1}
N -1840 760 -1780 760 {
lab=#net1}
N -1780 720 -1740 720 {
lab=Vdd}
N -1780 760 -1780 800 {
lab=#net1}
N -1780 860 -1780 910 {
lab=GND}
N -1780 740 -1720 740 {
lab=Vin1}
N -1900 1030 -1870 1030 {
lab=Vdd}
N -1870 1030 -1860 1030 {
lab=Vdd}
N -1900 1010 -1860 1010 {
lab=Vss}
N -1900 1050 -1860 1050 {
lab=Vin2}
N -1900 1070 -1860 1070 {
lab=#net2}
N -1860 1010 -1800 1010 {
lab=Vss}
N -1860 1030 -1800 1030 {
lab=Vdd}
N -1860 1050 -1800 1050 {
lab=Vin2}
N -1860 1070 -1800 1070 {
lab=#net2}
N -1800 1030 -1760 1030 {
lab=Vdd}
N -1800 1070 -1800 1110 {
lab=#net2}
N -1800 1170 -1800 1220 {
lab=GND}
N -1800 1050 -1740 1050 {
lab=Vin2}
N -2550 710 -2520 710 {
lab=Vdd}
N -2520 710 -2510 710 {
lab=Vdd}
N -2550 690 -2510 690 {
lab=Vss}
N -2550 730 -2510 730 {
lab=Vin3}
N -2550 750 -2510 750 {
lab=#net3}
N -2510 690 -2450 690 {
lab=Vss}
N -2510 710 -2450 710 {
lab=Vdd}
N -2510 730 -2450 730 {
lab=Vin3}
N -2510 750 -2450 750 {
lab=#net3}
N -2450 710 -2410 710 {
lab=Vdd}
N -2450 750 -2450 790 {
lab=#net3}
N -2450 850 -2450 900 {
lab=GND}
N -2450 730 -2390 730 {
lab=Vin3}
N -2570 1060 -2540 1060 {
lab=Vdd}
N -2540 1060 -2530 1060 {
lab=Vdd}
N -2570 1040 -2530 1040 {
lab=Vss}
N -2570 1080 -2530 1080 {
lab=Vin4}
N -2570 1100 -2530 1100 {
lab=#net4}
N -2530 1040 -2470 1040 {
lab=Vss}
N -2530 1060 -2470 1060 {
lab=Vdd}
N -2530 1080 -2470 1080 {
lab=Vin4}
N -2530 1100 -2470 1100 {
lab=#net4}
N -2470 1060 -2430 1060 {
lab=Vdd}
N -2470 1100 -2470 1140 {
lab=#net4}
N -2470 1200 -2470 1250 {
lab=GND}
N -2470 1080 -2410 1080 {
lab=Vin4}
N 380 -430 400 -430 {
lab=Vr}
N 370 -410 400 -410 {
lab=Vdac0}
N 1650 -460 1660 -460 {
lab=Vdac0}
C {/home/eserlis/vol_ref_gen.sym} -2410 160 0 0 {name=x1e}
C {/home/eserlis/bump_final.sym} 140 -420 0 0 {name=x2}
C {devices/vdd.sym} 370 -470 0 0 {name=l8 lab=Vdd}
C {devices/gnd.sym} 370 -320 0 0 {name=l11 lab=GND}
C {devices/lab_pin.sym} 360 -430 0 0 {name=p12 sig_type=std_logic lab=Vr
}
C {devices/lab_pin.sym} 630 -450 0 0 {name=p14 sig_type=std_logic lab=Iout00
}
C {devices/vdd.sym} -1210 -560 0 0 {name=l1 lab=Vdd}
C {devices/lab_pin.sym} -1210 -540 0 0 {name=p10 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} -1170 -440 0 0 {name=p16 sig_type=std_logic lab=Vdac0
}
C {devices/lab_pin.sym} -1140 -420 0 0 {name=p17 sig_type=std_logic lab=Vdac1
}
C {devices/lab_pin.sym} -1220 -520 0 0 {name=p18 sig_type=std_logic lab=Vin1
}
C {devices/lab_pin.sym} -1220 -500 0 0 {name=p19 sig_type=std_logic lab=Vin2
}
C {devices/lab_pin.sym} -1220 -480 0 0 {name=p20 sig_type=std_logic lab=Vin3
}
C {devices/lab_pin.sym} -1220 -460 0 0 {name=p21 sig_type=std_logic lab=Vin4}
C {/home/eserlis/dac.sym} -1410 -490 0 0 {name=x1}
C {/home/eserlis/ref_gen.sym} -1810 130 0 0 {name=x3}
C {devices/lab_pin.sym} -1620 120 0 0 {name=p15 sig_type=std_logic lab=En
}
C {devices/vdd.sym} -1620 100 0 0 {name=l3 lab=Vdd}
C {devices/lab_pin.sym} -1570 140 0 0 {name=p22 sig_type=std_logic lab=Ibias
}
C {devices/lab_pin.sym} -1630 190 0 0 {name=p24 sig_type=std_logic lab=Vss
}
C {devices/code.sym} -1920 -560 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

"
spice_ignore=false}
C {devices/code_shown.sym} -1230 -150 0 0 {name=NGSPICE
only_toplevel=true
value="
.control
.param Vin4bef=1.8 Vin3bef=1.8
.param Vin2bef=0 Vin1bef=1.8
.param W0=10 Wdac=10 Ldac=0.3
.param Wdac4=10 Ldac4=0.3
.param Wdac3=10 Ldac3=0.3
.param Wdac2=10 Ldac2=0.3
.param Wdac1=10 Ldac1=0.3
.param Wdac43=10 Ldac43=0.3
.param Wdac32=10 Ldac32=0.3
.param Wdac21=10 Ldac21=0.3
save all
tran 0.01n 100n
plot Iout0, Iout1
plot Vdac0, Vdac1, Vr
plot Vref1, Vref2, Vref3, Vref4
plot Vref5, Vref6, Vref7, Vref8
plot Vin1, Vin2, Vin3, Vin4
plot Iout02, Iout12
plot Ibias
write bump_tb.raw
.endc
" }
C {devices/vsource.sym} -630 750 0 0 {name=Vdd value=1.8 savecurrent=false}
C {devices/vdd.sym} -630 680 0 0 {name=l4 lab=Vdd}
C {devices/gnd.sym} -630 830 0 0 {name=l5 lab=GND}
C {devices/vsource.sym} -760 730 0 0 {name=Vss value=0
 savecurrent=false}
C {devices/gnd.sym} -760 810 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} -760 680 0 0 {name=p29 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} -630 700 0 0 {name=p30 sig_type=std_logic lab=Vdd
}
C {/home/eserlis/bump_final.sym} 170 270 0 0 {name=x6}
C {devices/vdd.sym} 400 220 0 0 {name=l12 lab=Vdd}
C {devices/gnd.sym} 400 370 0 0 {name=l15 lab=GND}
C {devices/lab_pin.sym} 390 280 0 0 {name=p33 sig_type=std_logic lab=Vr
}
C {devices/lab_pin.sym} 660 240 0 0 {name=p39 sig_type=std_logic lab=Iout10
}
C {/home/eserlis/bump_final.sym} 1420 -470 0 0 {name=x14}
C {devices/vdd.sym} 1650 -520 0 0 {name=l24 lab=Vdd}
C {devices/gnd.sym} 1650 -370 0 0 {name=l25 lab=GND}
C {devices/lab_pin.sym} 1650 -480 0 0 {name=p54 sig_type=std_logic lab=Vr}
C {devices/lab_pin.sym} 1910 -500 0 0 {name=p56 sig_type=std_logic lab=Iout02
}
C {devices/lab_pin.sym} 1780 -440 0 0 {name=p57 sig_type=std_logic lab=Iout00
}
C {/home/eserlis/bump_final.sym} 1460 280 0 0 {name=x15}
C {devices/vdd.sym} 1690 230 0 0 {name=l26 lab=Vdd}
C {devices/gnd.sym} 1690 380 0 0 {name=l27 lab=GND}
C {devices/lab_pin.sym} 1690 270 0 0 {name=p58 sig_type=std_logic lab=Vref4

}
C {devices/lab_pin.sym} 1680 290 0 0 {name=p59 sig_type=std_logic lab=Vr

}
C {devices/lab_pin.sym} 1950 250 0 0 {name=p60 sig_type=std_logic lab=Iout12
}
C {devices/lab_pin.sym} 1820 310 0 0 {name=p61 sig_type=std_logic lab=Iout10
}
C {devices/lab_pin.sym} 460 300 0 0 {name=p62 sig_type=std_logic lab=Ibias
}
C {devices/vsource.sym} -490 730 0 0 {name=Vr1 value=1.8 savecurrent=false}
C {devices/gnd.sym} -490 810 0 0 {name=l14 lab=GND}
C {devices/lab_pin.sym} -490 680 0 0 {name=p63 sig_type=std_logic lab=En
}
C {devices/vsource.sym} -350 750 0 0 {name=Vr value=0.8 savecurrent=false}
C {devices/gnd.sym} -350 830 0 0 {name=l28 lab=GND}
C {devices/lab_pin.sym} -350 700 0 0 {name=p64 sig_type=std_logic lab=Vr
}
C {devices/lab_pin.sym} 430 -390 0 0 {name=p35 sig_type=std_logic lab=Ibias
}
C {/home/eserlis/ccm_nmos.sym} 2980 -470 0 0 {name=x4}
C {devices/lab_pin.sym} 3220 -450 0 0 {name=p37 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} 3220 -470 0 0 {name=p38 sig_type=std_logic lab=Iclass0
}
C {devices/lab_pin.sym} 3220 -490 0 0 {name=p47 sig_type=std_logic lab=Iout02
}
C {/home/eserlis/ccm_nmos.sym} 3010 290 0 0 {name=x8}
C {devices/lab_pin.sym} 3250 310 0 0 {name=p48 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} 3250 290 0 0 {name=p49 sig_type=std_logic lab=Iclass1
}
C {devices/lab_pin.sym} 3250 270 0 0 {name=p50 sig_type=std_logic lab=Iout12
}
C {/home/eserlis/wta_pmos.sym} 3580 -30 0 0 {name=x9}
C {devices/lab_pin.sym} 3860 30 0 0 {name=p36 sig_type=std_logic lab=Ibias
}
C {devices/lab_pin.sym} 3820 -10 0 0 {name=p52 sig_type=std_logic lab=Iclass0
}
C {devices/lab_pin.sym} 3820 10 0 0 {name=p65 sig_type=std_logic lab=Iclass1
}
C {devices/lab_pin.sym} 3820 -50 0 0 {name=p66 sig_type=std_logic lab=Iout0
}
C {devices/vdd.sym} 3830 -90 0 0 {name=l6 lab=Vdd}
C {devices/lab_pin.sym} 3820 -70 0 0 {name=p69 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} 3920 -30 0 0 {name=p70 sig_type=std_logic lab=Iout1
}
C {devices/lab_pin.sym} -2190 170 0 0 {name=p1 sig_type=std_logic lab=Vss
}
C {devices/lab_pin.sym} -2190 190 0 0 {name=p2 sig_type=std_logic lab=Vref3
}
C {devices/lab_pin.sym} -2190 210 0 0 {name=p3 sig_type=std_logic lab=Vref4
}
C {devices/lab_pin.sym} -2190 150 0 0 {name=p4 sig_type=std_logic lab=Vref1
}
C {devices/vdd.sym} -2130 130 0 0 {name=l2 lab=Vdd}
C {devices/lab_pin.sym} -2190 110 0 0 {name=p5 sig_type=std_logic lab=Vref2
}
C {/home/eserlis/inv_layout.sym} -2030 730 0 0 {name=x10}
C {devices/lab_pin.sym} -1800 700 0 0 {name=p6 sig_type=std_logic lab=Vss
}
C {devices/vdd.sym} -1740 720 0 0 {name=l10 lab=Vdd}
C {devices/gnd.sym} -1780 910 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} -1730 740 0 0 {name=p7 sig_type=std_logic lab=Vin1
}
C {/home/eserlis/inv_layout.sym} -2050 1040 0 0 {name=x16}
C {devices/lab_pin.sym} -1820 1010 0 0 {name=p8 sig_type=std_logic lab=Vss
}
C {devices/vdd.sym} -1760 1030 0 0 {name=l19 lab=Vdd}
C {devices/gnd.sym} -1800 1220 0 0 {name=l20 lab=GND}
C {devices/lab_pin.sym} -1750 1050 0 0 {name=p11 sig_type=std_logic lab=Vin2
}
C {/home/eserlis/inv_layout.sym} -2700 720 0 0 {name=x17}
C {devices/lab_pin.sym} -2470 690 0 0 {name=p23 sig_type=std_logic lab=Vss
}
C {devices/vdd.sym} -2410 710 0 0 {name=l29 lab=Vdd}
C {devices/gnd.sym} -2450 900 0 0 {name=l30 lab=GND}
C {devices/lab_pin.sym} -2400 730 0 0 {name=p25 sig_type=std_logic lab=Vin3
}
C {/home/eserlis/inv_layout.sym} -2720 1070 0 0 {name=x18}
C {devices/lab_pin.sym} -2490 1040 0 0 {name=p26 sig_type=std_logic lab=Vss
}
C {devices/vdd.sym} -2430 1060 0 0 {name=l31 lab=Vdd}
C {devices/vsource.sym} -2470 1170 0 0 {name=Vdd7 value=Vin4bef
 savecurrent=false}
C {devices/gnd.sym} -2470 1250 0 0 {name=l32 lab=GND}
C {devices/lab_pin.sym} -2420 1080 0 0 {name=p27 sig_type=std_logic lab=Vin4
}
C {devices/vsource.sym} -2450 820 0 0 {name=Vdd1 value=Vin3bef
 savecurrent=false}
C {devices/vsource.sym} -1780 830 0 0 {name=Vdd2 value=Vin1bef
 savecurrent=false}
C {devices/vsource.sym} -1800 1140 0 0 {name=Vdd3 value=Vin2bef
 savecurrent=false}
C {devices/lab_pin.sym} 400 260 0 0 {name=p9 sig_type=std_logic lab=Vref4

}
C {devices/lab_pin.sym} 390 -410 0 0 {name=p13 sig_type=std_logic lab=Vdac0
}
C {devices/lab_pin.sym} 1650 -460 0 0 {name=p28 sig_type=std_logic lab=Vdac0
}
